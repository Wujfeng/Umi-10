# Keil uVision project STM32F401xx.uvproj, settings and files
target STM32F401xx (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F401xx +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER,STM32F40XX
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\USER;..\..\USER\SPI;..\..\USER\USART;..\..\USER\Delay;..\..\USER\Flash;..\..\USER\Command;..\..\USER\SCC2000;..\..\USER\BMI055;..\..\USER\Demarcate
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ../../Libraries/CMSIS/startup/: startup_stm32f401xx.s
  group USER
    ../../USER/: main.c stm32f4xx_it.c
    ../../USER/Delay/: Delay.c
    ../../USER/USART/: USART1.c
    ../../USER/SPI/: SPI1.c SPI2.c SPI3.c
    ../../USER/Flash/: Flash.c
    ../../USER/SCC2000/: SCC2000.c
    ../../USER/BMI055/: BMI055.c
    ../../USER/Command/: Command.c
    ../../USER/Demarcate/: Demarcate.c
  group FWlib
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f4xx.c

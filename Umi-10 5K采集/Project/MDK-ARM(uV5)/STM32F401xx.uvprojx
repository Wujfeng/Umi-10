# Keil uVision project STM32F401xx.uvprojx, settings and files
target STM32F401xx (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401CC STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401xx +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c misc: --C99
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\USER;..\..\USER\SPI;..\..\USER\USART;..\..\USER\Delay;..\..\USER\Flash;..\..\USER\Command;..\..\USER\SCC2000;..\..\USER\BMI055;..\..\USER\Demarcate
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../Libraries/CMSIS/startup/: startup_stm32f401xx.s
  group USER
    ../../USER/: main.c stm32f4xx_it.c ADS1258.c ADXRS453.c BMP280.c
    ../../USER/Delay/: Delay.c
    ../../USER/USART/: USART1.c
    ../../USER/SPI/: SPI1.c SPI2.c SPI3.c
    ../../USER/Flash/: Flash.c
    ../../USER/Command/: Command.c
    ../../USER/Demarcate/: Demarcate.c
  group FWlib
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/: system_stm32f4xx.c
